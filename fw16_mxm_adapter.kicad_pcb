# Repository PCModder803/fw16-mxm-adapter (continued)

## KiCad design fw16_mxm_adapter.kicad_pcb (continued)

Board: 6 copper layers, 92 parts (0 on the bottom side), 129 nets, no tracks yet.

Other parts of the board:
H1: MountingHole_2.2mm_M2
H2: MountingHole_2.7mm
H3, H4: MXM card hold-down (Type A and B); MountingHole_2.2mm_M2

File fw16_mxm_adapter_bom_draft.csv (part):

Reference,Value,Footprint,Notes
J1,FW16_ExpBay_Signal,fw16_mxm:FW16_FXBeam_Signal,Framework Expansion Bay signal interposer. Pinout from FrameworkComputer/ExpansionBay Electrical/README.md; place at the same XY as J2
J3,AS0B826-S55B-7H,fw16_mxm:MXM3_AS0B826-S55B-7H,"MXM 3.0 Type B socket (target X-Vision RX 6600 XT); S55B: 5.5 mm overall, 2.7 mm card gap (Critical Link; Foxconn's sheet doesn't state it); on a 1.2 mm adapter it needs the flat printed bay cover. Pinout from ADLINK/Advantech MXM 3.1 tables"
R20,0R,Resistor_SMD:R_0402_1005Metric,Host->card PCIe link: 0R (host TX already AC-coupled); fit 220nF instead if needed
R21,0R,Resistor_SMD:R_0402_1005Metric,Host->card PCIe link: 0R (host TX already AC-coupled); fit 220nF instead if needed
R22,0R,Resistor_SMD:R_0402_1005Metric,Host->card PCIe link: 0R (host TX already AC-coupled); fit 220nF instead if needed
R23,0R,Resistor_SMD:R_0402_1005Metric,Host->card PCIe link: 0R (host TX already AC-coupled); fit 220nF instead if needed
R24,0R,Resistor_SMD:R_0402_1005Metric,Host->card PCIe link: 0R (host TX already AC-coupled); fit 220nF instead if needed
R25,0R,Resistor_SMD:R_0402_1005Metric,Host->card PCIe link: 0R (host TX already AC-coupled); fit 220nF instead if needed
R26,0R,Resistor_SMD:R_0402_1005Metric,Host->card PCIe link: 0R (host TX already AC-coupled); fit 220nF instead if needed
R27,0R,Resistor_SMD:R_0402_1005Metric,Host->card PCIe link: 0R (host TX already AC-coupled); fit 220nF instead if needed
R28,0R,Resistor_SMD:R_0402_1005Metric,Host->card PCIe link: 0R (host TX already AC-coupled); fit 220nF instead if needed
R29,0R,Resistor_SMD:R_0402_1005Metric,Host->card PCIe link: 0R (host TX already AC-coupled); fit 220nF instead if needed
R30,0R,Resistor_SMD:R_0402_1005Metric,Host->card PCIe link: 0R (host TX already AC-coupled); fit 220nF instead if needed
R31,0R,Resistor_SMD:R_0402_1005Metric,Host->card PCIe link: 0R (host TX already AC-coupled); fit 220nF instead if needed
R32,0R,Resistor_SMD:R_0402_1005Metric,Host->card PCIe link: 0R (host TX already AC-coupled); fit 220nF instead if needed
R33,0R,Resistor_SMD:R_0402_1005Metric,Host->card PCIe link: 0R (host TX already AC-coupled); fit 220nF instead if needed
R34,0R,Resistor_SMD:R_0402_1005Metric,Host->card PCIe link: 0R (host TX already AC-coupled); fit 220nF instead if needed
R35,0R,Resistor_SMD:R_0402_1005Metric,Host->card PCIe link: 0R (host TX already AC-coupled); fit 220nF instead if needed
C10,220nF,Capacitor_SMD:C_0402_1005Metric,Card->host PCIe AC-coupling cap (MXM 3.1 sec 3.4.4: both directions on the system board)
C11,220nF,Capacitor_SMD:C_0402_1005Metric,Card->host PCIe AC-coupling cap (MXM 3.1 sec 3.4.4: both directions on the system board)
C12,220nF,Capacitor_SMD:C_0402_1005Metric,Card->host PCIe AC-coupling cap (MXM 3.1 sec 3.4.4: both directions on the system board)
C13,220nF,Capacitor_SMD:C_0402_1005Metric,Card->host PCIe AC-coupling cap (MXM 3.1 sec 3.4.4: both directions on the system board)
C14,220nF,Capacitor_SMD:C_0402_1005Metric,Card->host PCIe AC-coupling cap (MXM 3.1 sec 3.4.4: both directions on the system board)
C15,220nF,Capacitor_SMD:C_0402_1005Metric,Card->host PCIe AC-coupling cap (MXM 3.1 sec 3.4.4: both directions on the system board)
C16,220nF,Capacitor_SMD:C_0402_1005Metric,Card->host PCIe AC-coupling cap (MXM 3.1 sec 3.4.4: both directions on the system board)
C17,220nF,Capacitor_SMD:C_0402_1005Metric,Card->host PCIe AC-coupling cap (MXM 3.1 sec 3.4.4: both directions on the system board)
C18,220nF,Capacitor_SMD:C_0402_1005Metric,Card->host PCIe AC-coupling cap (MXM 3.1 sec 3.4.4: both directions on the system board)
C19,220nF,Capacitor_SMD:C_0402_1005Metric,Card->host PCIe AC-coupling cap (MXM 3.1 sec 3.4.4: both directions on the system board)
C20,220nF,Capacitor_SMD:C_0402_1005Metric,Card->host PCIe AC-coupling cap (MXM 3.1 sec 3.4.4: both directions on the system board)
C21,220nF,Capacitor_SMD:C_0402_1005Metric,Card->host PCIe AC-coupling cap (MXM 3.1 sec 3.4.4: both directions on the system board)
C22,220nF,Capacitor_SMD:C_0402_1005Metric,Card->host PCIe AC-coupling cap (MXM 3.1 sec 3.4.4: both directions on the system board)
C23,220nF,Capacitor_SMD:C_0402_1005Metric,Card->host PCIe AC-coupling cap (MXM 3.1 sec 3.4.4: both directions on the system board)
C24,220nF,Capacitor_SMD:C_0402_1005Metric,Card->host PCIe AC-coupling cap (MXM 3.1 sec 3.4.4: both directions on the system board)
C25,220nF,Capacitor_SMD:C_0402_1005Metric,Card->host PCIe AC-coupling cap (MXM 3.1 sec 3.4.4: both directions on the system board)
R41,0R,Resistor_SMD:R_0402_1005Metric,"PEX_RST# source: host PEX_RST# (default). Fit R41 OR R42, never both"
C26,100nF,Capacitor_SMD:C_0402_1005Metric,DP_A DC-blocking cap (MXM: on the system board)
C27,100nF,Capacitor_SMD:C_0402_1005Metric,DP_A DC-blocking cap (MXM: on the system board)
C28,100nF,Capacitor_SMD:C_0402_1005Metric,DP_A DC-blocking cap (MXM: on the system board)
C29,100nF,Capacitor_SMD:C_0402_1005Metric,DP_A DC-blocking cap (MXM: on the system board)
C30,100nF,Capacitor_SMD:C_0402_1005Metric,DP_A DC-blocking cap (MXM: on the system board)
C31,100nF,Capacitor_SMD:C_0402_1005Metric,DP_A DC-blocking cap (MXM: on the system board)
C32,100nF,Capacitor_SMD:C_0402_1005Metric,DP_A DC-blocking cap (MXM: on the system board)
C33,100nF,Capacitor_SMD:C_0402_1005Metric,DP_A DC-blocking cap (MXM: on the system board)
C34,100nF,Capacitor_SMD:C_0402_1005Metric,DP_A DC-blocking cap (MXM: on the system board)
C35,100nF,Capacitor_SMD:C_0402_1005Metric,DP_A DC-blocking cap (MXM: on the system board)
R1,330k 1%,Resistor_SMD:R_0603_1608Metric,"ID0: EC needs BOARD_VERSION_12 on both IDs (= dual interposer device), window 2040-2197 mV; 330k vs host 100k pull-up ~2.16 V if the pull-up rail is ~2.81 V (inferred from the EC's not-installed level). Forum t/74018 OP: 330k always detected; they believe the pull-up is 3.3 V, which would mean a different pull-up value. Measure on the first build"
R2,330k 1%,Resistor_SMD:R_0603_1608Metric,ID1: see R1
R3,4.7k,Resistor_SMD:R_0603_1608Metric,I2C pull-up
R4,4.7k,Resistor_SMD:R_0603_1608Metric,I2C pull-up
R5,10k,Resistor_SMD:R_0603_1608Metric,CLKREQ# pull-up
R8,10k,Resistor_SMD:R_0603_1608Metric,PROCHOT# pull-up
R6,10k,Resistor_SMD:R_0603_1608Metric,MXM PRSNT_R pull-up
R7,10k,Resistor_SMD:R_0603_1608Metric,MXM PRSNT_L pull-up
R14,100k DNP,Resistor_SMD:R_0603_1608Metric,DNP: not needed - MXM 3.1 Table 3.7: the module carries the 100k DP_A_HPD pull-down; system-side protection only
R13,0R,Resistor_SMD:R_0603_1608Metric,"PWR_GOOD -> power pin 53 = FBVDD_PWRGD in GPU mode. FW16 mainboard ANDs it with DGPU_PWROK into ALL_GPWRGD (7040 interface schematic p.3, UC77/UC78); left low, ALL_GPWRGD never asserts"
R36,7.15k 1%,Resistor_SMD:R_0603_1608Metric,"PEX_STD_SW# pull-down: MXM 3.1 Table 3.30 requires one for 8 GT/s systems; NC = short channel, 147k = medium, 7.15k / 0R = long. FW16 channel loss unknown: start at 7.15k"
R37,10k,Resistor_SMD:R_0603_1608Metric,PWR_GOOD pull-up: MXM 3.1 Table 3.11 requires 10k on the system board
R38,10k,Resistor_SMD:R_0603_1608Metric,TH_ALERT# pull-up: MXM 3.1 Table 3.11 requires one on the system board
U2,74LVC1G07,Package_TO_SOT_SMD:SOT-23-5,TI 74LVC1G07DBVR open-drain buffer: GPIO2_EC low (battery) -> MXM PWR_LEVEL low (reduced power). Leave U2 unfitted for always-full power. Needs descriptor gpio2 = GPIO_FUNC_ACDC / OUTPUT_LOW / POWER_S3
R39,100k,Resistor_SMD:R_0603_1608Metric,"GPIO2_EC pull-down: if the EC leaves the pin as an input (descriptor not changed), the card runs at reduced power rather than floating"
C44,100nF,Capacitor_SMD:C_0402_1005Metric,U2 VCC bypass
U3,BR24G32FVT-3GE2,Package_SO:TSSOP-8_4.4x3mm_P0.65mm,"Module EEPROM, 32 Kbit: EC reads 0x50 with 16-bit offsets. A0-A2=GND -> 0x50. WP=GND so the EC can program it. Contents: ExpansionBayConfigurationGenerator PCIE_THERMAL_3RDPARTY with PCIE_MUX_SEL low (keep DP_A AUX) and gpio2 = GPIO_FUNC_ACDC (drives PWR_LEVEL via U2)"
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

Notices in the files:
fw16_mxm_adapter.kicad_pcb:
Outline from Framework's RX 7700S module board (FW_GRAPHICS_MODULE_REF_00-1.stp, CC BY 4.0)
